# Keil uVision project OnBoardSDK_STM32.uvprojx, settings and files
target DJI_LIB (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: osdk_stm32 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,STM32,STM32F40x,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\Lib\CMSIS\inc;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\Lib\STM32F4x7_ETH_Driver\inc;..\User;..\Bsp;..\..\..\..\lib\inc;..\SYS;..\MAVLINK;..\ZKRT;..\MALLOC;..\HARDWARE;..\HARDWARE\SRAM;..\HARDWARE\ETHERNET;..\HARDWARE\os_module;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip_app\udp_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp cppforstm32.cpp Activate.cpp VirtualRC.cpp driver.cpp HotPoint.cpp Receive.cpp MobileCommand.cpp LocalNavigation.cpp
  group Bsp
    ../Bsp/: bsp.cpp timer.cpp BspUsart.cpp
  group doc
    ../doc/: readme.txt
  group LIB
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Lib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../Lib/CMSIS/src/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DJIlib
    ../../../../lib/src/: DJI_API.cpp DJI_App.cpp DJI_Camera.cpp DJI_Codec.cpp DJI_Flight.cpp DJI_Follow.cpp DJI_HardDriver.cpp DJI_HotPoint.cpp DJI_Link.cpp DJI_Memory.cpp DJI_Mission.cpp DJI_VirtualRC.cpp DJI_WayPoint.cpp
  group SYS
    ../SYS/: sys.c sys.h usart.c usart.h
  group HARDWARE
    ../HARDWARE/: adc.c adc.h timer_zkrt.c timer_zkrt.h led.c led.h iic.c iic.h flash.c flash.h can.c can.h ds18b20.c ds18b20.h iwatchdog.c iwatchdog.h sbus.c sbus.h bat.c bat.h app.c app.h
    ../HARDWARE/ETHERNET/: lan8720.c
    ../HARDWARE/SRAM/: sram.c
  group HARDWARE_OS
    ../HARDWARE/os_module/: osqtmr.c ostmr.c ostmr0.c ostmr1.c
  group MAVLINK
    ../MAVLINK/: mavlink.c mavlink.h mavlink_msg_heartbeat.c mavlink_msg_heartbeat.h mavlink_msg_management_module.c mavlink_msg_management_module.h mavlink_msg_smartbat_text.c mavlink_msg_smartbat_text.h mavlink_msg_statustext .c mavlink_msg_statustext.h mavlink_msg_statustext-ref.h mavlink_types.h
  group ZKRT
    ../ZKRT/: zkrt.c zkrt.h djiapp.c djiapp.h heart.c heart.h tempture.c tempture.h mobileDataHandle.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../LWIP/lwip_app/: lwipapp.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
  group MALLOC
    ../MALLOC/: malloc.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.3.1
